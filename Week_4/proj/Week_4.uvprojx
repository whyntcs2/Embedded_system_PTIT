# Keil uVision project Week_4.uvprojx, settings and files
target Week_4 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Week_4
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\inc;..\src;..\FreeRTOS\include;..\FreeRTOS\protable\ARM_CM3
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group inc
    ../inc/: FreeRTOSConfig.h
  group src
    ../src/: main.c
  group FreeRTOS
    ../FreeRTOS/: list.c queue.c tasks.c
    ../FreeRTOS/protable/ARM_CM3/: port.c
    ../FreeRTOS/protable/MemMang/: heap_4.c
software components: CMSIS:CORE 5.4.0, Device:Startup 1.0.0, Device:StdPeriph Drivers:Framework 3.6.0, Device:StdPeriph Drivers:GPIO 3.6.0, Device:StdPeriph Drivers:RCC 3.6.0
